SRC_URI += "file://bsp.cfg \
            file://user_2018-11-10-14-15-00.cfg \
            file://user_2018-11-11-13-46-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
